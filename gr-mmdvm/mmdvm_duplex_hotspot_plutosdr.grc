options:
  parameters:
    description: Based on kantooon's QRadioLink MMDVM Flowgraph for mmdvm-sdr
    generate_options: qt_gui
    id: mmdvm_modem
    output_language: python
    title: MMDVM Duplex Hotspot Mod/Demod for PlutoSDR
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    label: Audio Gain
    orient: Qt.Horizontal
    start: '0'
    step: '.01'
    stop: '1'
    value: '0.99'
  states: {}
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    label: Baseband Gain
    orient: Qt.Horizontal
    start: '0'
    step: '.01'
    stop: '1'
    value: '1'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: '1700'
  states: {}
- name: decim_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: filter_width
    gain: '3'
    samp_rate: samp_rate * 3
    width: '500'
    win: firdes.WIN_BLACKMAN
  states: {}
- name: decoder_volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Audio Volume
    orient: Qt.Horizontal
    start: '0'
    step: '.01'
    stop: '1'
    value: '0.02'
  states: {}
- name: demod_level
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    label: Demod Level
    orient: Qt.Horizontal
    start: '0'
    step: '.01'
    stop: '10'
    value: '0.1'
  states: {}
- name: fft_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: filter_width
    gain: '1'
    samp_rate: 'target_samp_rate '
    width: '90'
    win: firdes.WIN_BLACKMAN
  states: {}
- name: filter_width
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: interp_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: filter_width
    gain: sps
    samp_rate: samp_rate * 3
    width: '90'
    win: firdes.WIN_BLACKMAN
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: RF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '.01'
    stop: '1'
    value: '0.8'
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: RX Frequency
    orient: Qt.Horizontal
    start: 70e6
    step: 100e3
    stop: 440e6
    value: 435.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '125'
  states: {}
- name: target_samp_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: tx_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: TX Frequency
    orient: Qt.Horizontal
    start: 70e6
    step: 100e3
    stop: 440e6
    value: 435e6
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 4*pi*filter_width/target_samp_rate
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.01'
    gate: 'True'
    ramp: '0'
    threshold: '-140'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: float(target_samp_rate)/(4*pi* float(filter_width))
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: target_samp_rate*2
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: rf_gain
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: bb_gain
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: demod_level
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: decoder_volume
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: dsd_block_ff_0
  id: dsd_block_ff
  parameters:
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    mod: dsd.dsd_MOD_AUTO_SELECT
    uvquality: '3'
    verbosity: '2'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: fft_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: fft_filter_taps
    type: ccc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    auto_filter: 'True'
    bandwidth: int(samp_rate)
    buffer_size: '32768'
    cyclic: 'False'
    frequency: int(tx_freq)
    samplerate: int(samp_rate)
    uri: ip:192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: int(samp_rate)
    bbdc: 'True'
    buffer_size: '32768'
    frequency: int(rx_freq)
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    uri: ip:192.168.2.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,2,1
    name: '"MMDVM TX"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 144.5e6
    fftsize: '1024'
    gui_hint: 0,1,2,1
    name: '"MMDVM RX"'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_base_xxx_0
  id: rational_resampler_base_xxx
  parameters:
    decim: '3'
    interp: sps
    taps: interp_taps
    type: ccc
  states: {}
- name: rational_resampler_base_xxx_0_0
  id: rational_resampler_base_xxx
  parameters:
    decim: sps
    interp: '3'
    taps: decim_taps
    type: ccc
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '6'
    taps: ''
    type: fff
  states: {}
- name: zeromq_pull_source_1
  id: zeromq_pull_source
  parameters:
    address: ipc:///tmp/mmdvm-tx.ipc
    timeout: '100'
    type: short
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: ipc:///tmp/mmdvm-rx.ipc
    timeout: '100'
    type: short
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [blocks_float_to_short_0, '0', zeromq_push_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', fft_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', rational_resampler_base_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', blocks_float_to_short_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_short_to_float_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_short_to_float_0, '0', rational_resampler_xxx_0, '0']
- [dsd_block_ff_0, '0', rational_resampler_xxx_0_0, '0']
- [fft_filter_xxx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [fft_filter_xxx_0_0, '0', analog_pwr_squelch_xx_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_0_0, '0']
- [iio_pluto_source_0, '0', rational_resampler_base_xxx_0_0, '0']
- [rational_resampler_base_xxx_0, '0', iio_pluto_sink_0, '0']
- [rational_resampler_base_xxx_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_base_xxx_0_0, '0', fft_filter_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', dsd_block_ff_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [zeromq_pull_source_1, '0', blocks_short_to_float_0, '0']

metadata:
  file_format: 1
